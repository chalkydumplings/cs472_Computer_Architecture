# Keil uVision project block_move.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: block_move
  c flags: Optim=1
  scatter file: block_move.sct
  group Source Group 1
    ./: block_move.s
