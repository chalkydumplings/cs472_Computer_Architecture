# Keil uVision project avg_vector.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM966E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S) EBIG
  output: avg_vector
  c flags: Optim=1
  group Source Group 1
    ./: avg_vector.s
